options:
  parameters:
    generate_options: qt_gui
    id: audio_tx_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label0: '"song1"'
    label1: '"song2"'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 400e6
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '40000'
    fh: '-1'
    max_dev: 75e3
    quad_rate: '400000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/Desktop/project/assets/Souraa.mp3
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/Desktop/project/assets/National_Anthem.mp3
    repeat: 'True'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport os\nfrom pydub import AudioSegment\n\nclass myblock(gr.sync_block):\n    \"\"\"\n    Custom block to stream an MP3 file from a folder based on a selection value (weight).\n    \"\"\"\n    def __init__(self, folder_path=\"/home/pi/Desktop/project/assets\", weight=1):\n        # Initialize the block with no inputs and one output\n        gr.sync_block.__init__(self,\n            name=\"myblock\",\n            in_sig=None,\n            out_sig=[np.float32])\n\n        self.folder_path = folder_path\n        self.weight = weight\n        self.previous_weight = weight  # Store the previous weight to detect changes\n        self.audio_position = 0\n        self.selected_audio = None\n        \n        # Load and validate MP3 files in the directory\n        self.mp3_files = sorted([f for f in os.listdir(folder_path) if f.endswith('.mp3')])\n        if not self.mp3_files:\n            raise ValueError(\"No MP3 files found in the specified folder.\")\n        \n        # Load the initial MP3 file based on the weight index\n        self.load_mp3_by_weight()\n\n    def load_mp3_by_weight(self):\n        \"\"\" Load the MP3 file corresponding to the current weight index \"\"\"\n        if self.weight >= 0 and self.weight < len(self.mp3_files):\n            filename = self.mp3_files[self.weight]\n            self.load_mp3(filename)\n        else:\n            raise ValueError(\"Invalid weight index: out of range for available MP3 files.\")\n\n    def load_mp3(self, filename):\n        \"\"\" Load the selected MP3 file as raw PCM audio data \"\"\"\n        audio_path = os.path.join(self.folder_path, filename)\n        audio = AudioSegment.from_mp3(audio_path)\n        \n        # Convert to raw PCM 32-bit float data\n        samples = np.array(audio.get_array_of_samples())\n        \n        # If the audio is stereo, flatten the samples\n        if audio.channels == 2:\n            samples = samples.reshape((-1, 2)).mean(axis=1)\n        \n        # Normalize to the range [-1, 1]\n        self.selected_audio = samples.astype(np.float32) / np.iinfo(audio.array_type).max\n        \n        # Reset audio position\n        self.audio_position = 0\n        print(f\"Loaded MP3 file: {filename}, Total samples: {len(self.selected_audio)}\")\n\n    def check_and_update_weight(self):\n        \"\"\" Check if the weight has changed, and update the MP3 file if it has \"\"\"\n        if self.weight != self.previous_weight:\n            print(f\"Weight changed from {self.previous_weight} to {self.weight}\")\n            self.previous_weight = self.weight\n            self.load_mp3_by_weight()\n            self.reset_audio_stream()\n\n    def reset_audio_stream(self):\n        \"\"\" Clear the output buffer to start streaming the new audio immediately \"\"\"\n        self.audio_position = 0  # Reset position to the beginning of the new audio\n\n    def work(self, input_items, output_items):\n        # Check if the weight has changed and update if necessary\n        self.check_and_update_weight()\n\n        # Determine how many samples we need to output\n        num_samples = len(output_items[0])\n\n        if self.selected_audio is None:\n            output_items[0][:] = np.zeros(num_samples)\n            return num_samples\n\n        # Output the selected portion of the audio file\n        start = self.audio_position\n        end = start + num_samples\n\n        if end <= len(self.selected_audio):\n            output_items[0][:] = self.selected_audio[start:end]\n            self.audio_position = end\n        else:\n            # If we've reached the end of the audio, pad with zeros\n            valid_samples = len(self.selected_audio) - start\n            output_items[0][:valid_samples] = self.selected_audio[start:]\n            output_items[0][valid_samples:] = 0\n            self.audio_position = len(self.selected_audio)  # Stop streaming\n            print(\"Reached the end of the audio stream\")\n\n        return num_samples\n\n# Example usage:\n# block = myblock(folder_path=\"/path/to/mp3/folder\", weight=2)\n# block.weight = 1  # Changing the weight during runtime\n"
    folder_path: '"/home/pi/Desktop/project/assets"'
    weight: variable_qtgui_chooser_0
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      # import numpy as np
      # from gnuradio import gr
      # import pmt
      # import os
      # from gtts import gTTS
      # from pydub import AudioSegment

      # class text_to_wav_block(gr.sync_block):  
      #     """Embedded Python Block example - converts text to WAV and outputs float32 data"""

      #     def __init__(self, sample_rate=48000):  
      #         """arguments to this function show up as parameters in GRC"""
      #         gr.sync_block.__init__(
      #             self,
      #             name='text_to_wav_block',   # will show up in GRC
      #             in_sig=[],
      #             out_sig=[np.float32]  # Output signal as float32
      #         )
      #         self.sample_rate = sample_rate
      #         self.text = "no input"
      #         self.filename = "output.wav"
      #         self.wav_data = np.array([], dtype=np.float32)  # Initialize an empty array for WAV data
      #         self.message_port_register_in(pmt.intern("MSG_IN"))
      #         self.set_msg_handler(pmt.intern("MSG_IN"), self.set_text)

      #     def set_text(self, msg):
      #         """
      #         Sets the text to be converted to WAV.
      #         """
      #         self.text = str(msg)
      #         print(msg)
      #         self.convert_to_wav()

      #     def convert_to_wav(self):
      #         """
      #         Converts the stored text to a WAV file and loads the WAV data for output.
      #         """
      #         if self.text:
      #             tts = gTTS(text=self.text, lang='en')
      #             tts.save("temp.mp3")  # Save as mp3 temporarily

      #             # Convert mp3 to wav
      #             sound = AudioSegment.from_mp3("temp.mp3")
      #             sound = sound.set_frame_rate(self.sample_rate)  # Ensure correct sample rate
      #             sound.export(self.filename, format="wav")
      #             print(f"Audio saved as {self.filename}")
                  
      #             # Load the WAV data into memory as a numpy array
      #             self.wav_data = np.array(sound.get_array_of_samples(), dtype=np.float32)
                  
      #             # Normalize the data to the range [-1, 1]
      #             self.wav_data /= np.iinfo(np.int16).max
                  
      #             # Clean up the temporary mp3 file
      #             os.remove("temp.mp3")
      #         else:
      #             print("No text provided for conversion.")

      #     def work(self, input_items, output_items):
      #         """Output the float32 WAV data"""
      #         output_length = len(output_items[0])
      #         data_length = len(self.wav_data)
              
      #         # Ensure we don't exceed the length of the WAV data
      #         if data_length > 0:
      #             output_items[0][:min(output_length, data_length)] = self.wav_data[:min(output_length, data_length)]
      #             self.wav_data = self.wav_data[min(output_length, data_length):]  # Update remaining data
      #         else:
      #             output_items[0][:] = 0  # No data to output

      #         return len(output_items[0])



      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      from gtts import gTTS
      from pydub import AudioSegment

      class text_to_wav_block(gr.sync_block):  
          """Embedded Python Block - converts text to WAV and streams float32 data"""

          def __init__(self, sample_rate=48000):  
              """Arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='text_to_wav_block',   # Will show up in GRC
                  in_sig=[],
                  out_sig=[np.float32]  # Output signal as float32
              )
              self.sample_rate = sample_rate
              self.text = "no input"
              self.filename = "output.wav"
              self.wav_data = np.array([], dtype=np.float32)  # Initialize an empty array for WAV data
              self.message_port_register_in(pmt.intern("MSG_IN"))
              self.set_msg_handler(pmt.intern("MSG_IN"), self.set_text)
              self.data_index = 0  # To keep track of where we are in the wav_data

          def set_text(self, msg):
              """
              Sets the text to be converted to WAV.
              """
              self.text = str(pmt.symbol_to_string(msg))
              print(f"Received text: {self.text}")
              self.convert_to_wav()
              self.data_index = 0  # Reset the data index when new text is received

          def convert_to_wav(self):
              """
              Converts the stored text to a WAV file and loads the WAV data for output.
              """
              try:
                  tts = gTTS(text=self.text, lang='en')
                  tts.save("temp.mp3")  # Save as mp3 temporarily

                  # Convert mp3 to wav
                  sound = AudioSegment.from_mp3("temp.mp3")
                  sound = sound.set_frame_rate(self.sample_rate)  # Ensure correct sample rate
                  sound.export(self.filename, format="wav")
                  print(f"Audio saved as {self.filename}")
                  
                  # Load the WAV data into memory as a numpy array
                  self.wav_data = np.array(sound.get_array_of_samples(), dtype=np.float32)
                  
                  # Normalize the data to the range [-1, 1]
                  self.wav_data /= np.iinfo(np.int16).max
                  
                  # Clean up the temporary mp3 file
                  os.remove("temp.mp3")
              except Exception as e:
                  print(f"Error in convert_to_wav: {e}")
                  self.wav_data = np.array([], dtype=np.float32)  # Reset on error

          def work(self, input_items, output_items):
              """Stream the float32 WAV data continuously until a new message is received"""
              output_length = len(output_items[0])
              data_length = len(self.wav_data)

              if data_length > 0:
                  for i in range(output_length):
                      output_items[0][i] = self.wav_data[self.data_index]
                      self.data_index += 1
                      if self.data_index >= data_length:
                          self.data_index = 0  # Loop back to the start of wav_data
              else:
                  output_items[0][:] = 0  # Output silence if no data

              return len(output_items[0])
    sample_rate: '32000'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"enter message"'
    type: string
    value: '"hello world"'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '50'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '50'
    type: fff
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 107.5e6
    gain0: '50'
    samp_rate: '2000000'
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 107.5e6
    gain0: '50'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '11'
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', analog_wfm_tx_0, '0']
- [epy_block_1_0_0, '0', analog_wfm_tx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [qtgui_edit_box_msg_0_0_0, msg, epy_block_1_0_0, MSG_IN]
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
