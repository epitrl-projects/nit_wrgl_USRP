options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: uhd_packet_mavlink_rpi
    output_language: python
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {state: disabled}
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Amplitude
    start: '0'
    step: '0.005'
    stop: '0.9'
    value: '0.5'
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_hdr
  id: variable_dummy_decoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: 1500*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: enc_hdr
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency
    start: 50e6
    step: 500e3
    stop: 3e9
    value: 2483e6-300
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '83'
    value: '50'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: digital.packet_utils.default_access_code
    bps: '1'
    threshold: '3'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: len(tx_rrc_taps)
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: sps*nfilts
    sym_rate: '1.0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    start: 200e3
    step: 200e3
    stop: 10e6
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 5*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp*2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp*50
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: packet_len
    type: complex
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: eb
    samps_per_sym: sps
    type: cc
    w: '0.05'
  states: {}
- name: packet_rx_0
  id: packet_rx
  parameters:
    eb: eb
    hdr_const: Const_HDR
    hdr_dec: dec_hdr
    hdr_format: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    pld_const: Const_PLD
    pld_dec: dec
    psf_taps: rx_rrc_taps
    sps: sps
  states: {}
- name: packet_tx_0
  id: packet_tx
  parameters:
    hdr_const: Const_HDR
    hdr_enc: enc_hdr
    hdr_format: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    pld_const: Const_PLD
    pld_enc: enc
    psf_taps: tx_rrc_taps
    sps: sps
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab0@2
    legend: 'False'
    size: '1024'
    tr_tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab0@1
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab0@0
    label1: ''
    label2: ''
    legend: 'False'
    size: '250000'
    srate: '1'
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {}
- name: uaslink_pymavlink_source_sink_pp_0
  id: uaslink_pymavlink_source_sink_pp
  parameters:
    baud_rate: '57600'
    connection_string: '''/dev/ttyUSB0'''
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"serial=30CF9AE"'
    dev_args: '""'
    gain0: gain
    len_tag_name: packet_len
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"serial=3116746"'
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate*5
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(freq, samp_rate/2.0)
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_tag_debug_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_null_sink_0, '0']
- [digital_fll_band_edge_cc_0, '0', packet_rx_0, '0']
- [packet_rx_0, pkt out, blocks_message_debug_0, print]
- [packet_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [uaslink_pymavlink_source_sink_pp_0, MAVLink_OUT, packet_tx_0, in]
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_1, '0', digital_fll_band_edge_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
