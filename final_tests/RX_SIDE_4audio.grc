options:
  parameters:
    category: Custom
    description: Example of an OFDM receiver
    generate_options: qt_gui
    id: RX_SIDE_4audio
    output_language: python
    title: OFDM Tx Rx
  states: {}

blocks:
- name: RX_GAIN_0
  id: variable_qtgui_range
  parameters:
    label: RX_GAIN
    start: '0'
    step: '1'
    stop: '1000'
    value: '40'
  states: {}
- name: TX_GAIN
  id: variable_qtgui_range
  parameters:
    label: TX_GAIN
    start: '10'
    step: '1'
    stop: '1000'
    value: '40'
  states: {}
- name: central_freq
  id: variable
  parameters:
    value: 915e6
  states: {state: disabled}
- name: central_freq
  id: variable_qtgui_range
  parameters:
    label: TX FREQ
    start: 915e6
    step: 1e6
    stop: 10000e6
    value: 915e6
  states: {}
- name: central_freq_0
  id: variable_qtgui_range
  parameters:
    label: RX_FREQ
    start: 915e6
    step: 1e6
    stop: 10000e6
    value: 915e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_16qam()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: TX_SAMPLE
    start: '0'
    step: '1'
    stop: '500000'
    value: '100000'
  states: {}
- name: samp_rate_0
  id: variable_qtgui_range
  parameters:
    label: RX_SAMPLE
    start: '0'
    step: '1'
    stop: '500000'
    value: '100000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label0: '"song0"'
    label1: '"song1"'
    label2: '"song2"'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '40000'
    fh: '-1'
    max_dev: 75e3
    quad_rate: '400000'
    tau: '75e-6'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: rx_frames_time
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pi/Desktop/project/mytests/demo.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("0")
    period: '1000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: packet_length_tag_key
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_length_tag_key
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_length_tag_key
    packet_len: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '96'
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: packet_length_tag_key
    name: Rx Bytes
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_length_tag_key
    ninputs: '2'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 0.7+ 0.7j
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {state: disabled}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate_0
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: packet_length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {state: disabled}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    tagname: packet_length_tag_key
  states: {state: disabled}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.99'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: packet_length_tag_key
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class message_to_int8(gr.sync_block):
          """
          A GNU Radio block that converts messages to int8 format and outputs them.
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="message_to_int8",  # Block name
                  in_sig=None,             # No direct input
                  out_sig=[np.int8]        # Output signal type
              )

              # Register a message port
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # Buffer to store the int8 data
              self.output_data = np.array([], dtype=np.int8)

          def handle_msg(self, msg):
              # Convert the input PMT message to a string
              str_data = pmt.symbol_to_string(msg)
              
              # Convert string to int8 numpy array
              int8_data = np.frombuffer(str_data.encode('utf-8'), dtype=np.int8)
              
              # Append the int8 data to the buffer
              self.output_data = np.append(self.output_data, int8_data)
              

          def work(self, input_items, output_items):
              # Determine how much data we can output
              n_output_items = min(len(self.output_data), len(output_items[0]))
              #print("sender",n_output_items)
              
              if n_output_items > 0:
                  # Copy the data to the output
                  output_items[0][:n_output_items] = self.output_data[:n_output_items]
                  
                  # Remove the outputted data from the buffer
                  self.output_data = self.output_data[n_output_items:]
              
              # Return the number of items produced
              return n_output_items
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport os\nfrom pydub import AudioSegment\n\nclass myblock(gr.sync_block):\n    \"\"\"\n    Custom block to stream an MP3 file from a folder based on a selection value (weight).\n    \"\"\"\n    def __init__(self, folder_path=\"/home/pi/Desktop/project/assets\"):\n        # Initialize the block with no inputs and one output\n        gr.sync_block.__init__(self,\n            name=\"myblock\",\n            in_sig=None,\n            out_sig=[np.float32])\n\n        self.folder_path = folder_path\n        self.weight = 0\n        self.previous_weight = 0  # Store the previous weight to detect changes\n        self.audio_position = 0\n        self.selected_audio = None\n        self.previouscheckweight = 0\n        \n        # Load and validate MP3 files in the directory\n        self.mp3_files = sorted([f for f in os.listdir(folder_path) if f.endswith('.mp3')])\n        if not self.mp3_files:\n            raise ValueError(\"No MP3 files found in the specified folder.\")\n        if(self.weight>0):\n            # Load the initial MP3 file based on the weight index\n            self.load_mp3_by_weight()\n        # Register an input message port\n        self.message_port_register_in(gr.pmt.intern(\"weight_msg\"))\n        self.set_msg_handler(gr.pmt.intern(\"weight_msg\"), self.handle_msg)\n\n    def load_mp3_by_weight(self):\n        \"\"\" Load the MP3 file corresponding to the current weight index \"\"\"\n        if  self.weight < len(self.mp3_files):\n            filename = self.mp3_files[self.weight]\n            self.load_mp3(filename)\n        else:\n            raise ValueError(\"Invalid weight index: out of range for available MP3 files.\")\n\n    def handle_msg(self, msg):\n            \"\"\" Handle incoming messages to update the weight \"\"\"\n            # Convert the message to an integer (assumes the message is a string or integer PMT)\n            new_weight = int(gr.pmt.to_python(msg))\n            print(f\"Received new weight: {new_weight}\")\n            print(self.mp3_files)\n            if  self.weight < len(self.mp3_files):\n                if(self.previouscheckweight!=new_weight):\n                    self.weight = new_weight\n                    self.check_and_update_weight()\n                    self.previouscheckweight = new_weight\n            \n        \n    def load_mp3(self, filename):\n        \"\"\" Load the selected MP3 file as raw PCM audio data \"\"\"\n        audio_path = os.path.join(self.folder_path, filename)\n        audio = AudioSegment.from_mp3(audio_path)\n        \n        # Convert to raw PCM 32-bit float data\n        samples = np.array(audio.get_array_of_samples())\n        \n        # If the audio is stereo, flatten the samples\n        if audio.channels == 2:\n            samples = samples.reshape((-1, 2)).mean(axis=1)\n        \n        # Normalize to the range [-1, 1]\n        self.selected_audio = samples.astype(np.float32) / np.iinfo(audio.array_type).max\n        \n        # Reset audio position\n        self.audio_position = 0\n        print(f\"Loaded MP3 file: {filename}, Total samples: {len(self.selected_audio)}\")\n\n    def check_and_update_weight(self):\n        \"\"\" Check if the weight has changed, and update the MP3 file if it has \"\"\"\n        if self.weight != self.previous_weight:\n            print(f\"Weight changed from {self.previous_weight} to {self.weight}\")\n            self.previous_weight = self.weight\n            self.load_mp3_by_weight()\n            self.reset_audio_stream()\n\n    def reset_audio_stream(self):\n        \"\"\" Clear the output buffer to start streaming the new audio immediately \"\"\"\n        self.audio_position = 0  # Reset position to the beginning of the new audio\n\n    def work(self, input_items, output_items):\n        # Check if the weight has changed and update if necessary\n        self.check_and_update_weight()\n\n        # Determine how many samples we need to output\n        num_samples = len(output_items[0])\n\n        if self.selected_audio is None:\n            output_items[0][:] = np.zeros(num_samples)\n            return num_samples\n\n        # Output the selected portion of the audio file\n        start = self.audio_position\n        end = start + num_samples\n\n        if end <= len(self.selected_audio):\n            output_items[0][:] = self.selected_audio[start:end]\n            self.audio_position = end\n        else:\n            # If we've reached the end of the audio, pad with zeros\n            valid_samples = len(self.selected_audio) - start\n            output_items[0][:valid_samples] = self.selected_audio[start:]\n            output_items[0][valid_samples:] = 0\n            self.audio_position = len(self.selected_audio)  # Stop streaming\n            print(\"Reached the end of the audio stream\")\n\n        return num_samples\n\n# Example usage:\n# block = myblock(folder_path=\"/path/to/mp3/folder\", weight=2)\n# block.weight = 1  # Changing the weight during runtime\n"
    folder_path: '"/home/pi/Desktop/project/assets"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass int8_to_message(gr.sync_block):\n    \"\"\"\n    A GNU Radio block that converts int8 input to a string and sends it as a message to update a QT GUI Chooser.\n    \"\"\"\n\n    def __init__(self,chooser_block=None):\n        gr.sync_block.__init__(\n            self,\n            name=\"int8_to_message\",  # Block name\n            in_sig=[np.int8],        # Input signal type\n            out_sig=None             # No direct output\n        )\n        \n        # Register an output message port\n        self.message_port_register_out(pmt.intern(\"msg_out\"))\n        self.chooser_block = chooser_block\n\n    def work(self, input_items, output_items):\n        # Convert int8 input to a byte array\n        byte_array = input_items[0].tobytes()\n        \n        # Convert byte array to string\n        converted_string = byte_array.decode('utf-8')\n        print(\"data received\",converted_string)\n        converted_string = converted_string[-1]\n        \n        #self.chooser_block=int(converted_string)\n        \n        # Convert string to a PMT symbol\n        msg = pmt.intern(converted_string)\n        \n        # Send the message out\n        self.message_port_pub(pmt.intern(\"msg_out\"), msg)\n        \n        return len(input_items[0])\n\n"
    chooser_block: variable_qtgui_chooser_0
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class message_file_sink_source(gr.basic_block):
          def __init__(self, file_path="/home/pi/Desktop/project/mytests/demo.txt"):
              # Define the block with no input streaming, only message input
              # Output signal is a byte stream (np.uint8)
              gr.basic_block.__init__(self,
                  name="message_file_sink_source",
                  in_sig=None,  # No streaming input
                  out_sig=[np.uint8])  # Output byte stream

              # Register the message input port
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_message)

              # File path for saving the data
              self.file_path = file_path

              # Initialize source file as None
              self.source_file = None
              self.bytes_written = False  # Flag to track whether data has been written

          def handle_message(self, msg):
              # Handle incoming messages from the message strobe
              if pmt.is_symbol(msg):
                  # If message is a string (symbol), encode it as bytes
                  data = pmt.symbol_to_string(msg).encode('utf-8')
              elif pmt.is_u8vector(msg):
                  # If message is a u8vector (byte array), convert to a numpy array
                  data = np.array(pmt.u8vector_elements(msg), dtype=np.uint8).tobytes()
              else:
                  print("Unsupported message type.")
                  return

              # Open the file in write mode ('wb') to replace previous content
              with open(self.file_path, 'wb') as sink_file:
                  # Write the new data to the file and flush to ensure it's saved
                  for i in range(10):
                      data +=data
                  sink_file.write(data)
                  sink_file.flush()

              # Set flag to true, indicating data has been written
              self.bytes_written = True

              # Re-open the file for reading after writing is done
              if self.source_file is None or self.source_file.closed:
                  self.source_file = open(self.file_path, 'rb')

          def general_work(self, input_items, output_items):
              # If no data has been written yet, output nothing
              if not self.bytes_written:
                  return 0

              # Read bytes from the file in chunks and send them to the output
              output_len = len(output_items[0])

              # Ensure source file is open for reading
              if self.source_file is None or self.source_file.closed:
                  self.source_file = open(self.file_path, 'rb')

              # Try to read `output_len` bytes from the source file
              data = self.source_file.read(output_len)

              if not data:
                  # If EOF is reached or no more data, close the source file
                  self.source_file.close()
                  self.bytes_written = False  # Reset the flag for future messages
                  return 0  # No items produced

              # Convert data to numpy uint8 format for output
              output_items[0][:len(data)] = np.frombuffer(data, dtype=np.uint8)

              # Consume no input and produce the number of output items generated
              self.consume_each(0)  # We are not consuming from any input
              return len(data)

          def stop(self):
              # Close the source file when the flowgraph stops
              if self.source_file:
                  self.source_file.close()
              return True
    file_path: '''/home/pi/Desktop/project/mytests/demo.txt'''
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx payload"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"ENTER SONG NUMBER"'
    type: string
    value: '"0"'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: '"Rx signal"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Tx freq"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Rx packed"'
    size: '1024'
    srate: samp_rate_0
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '50'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 107.0e6
    gain0: '50'
    samp_rate: '2000000'
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: central_freq
    dev_addr: ''
    gain0: TX_GAIN
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: central_freq_0
    dev_args: '""'
    gain0: RX_GAIN_0
    rx_agc0: Disabled
    samp_rate: samp_rate_0
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: '11'
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {state: disabled}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: '22'
  states: {state: disabled}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: '33'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: '11'
  states: {state: disabled}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {state: disabled}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {state: disabled}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: '33'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, msg_in]
- [blocks_message_strobe_0, strobe, epy_block_2, in]
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_2_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_1, '0', epy_block_1, '0']
- [blocks_stream_to_tagged_stream_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tag_gate_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_1, '0']
- [blocks_tag_gate_0, '0', virtual_sink_2, '0']
- [blocks_tagged_stream_mux_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_0_0_0_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_delay_0, '0']
- [channels_channel_model_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [digital_crc32_bb_0, '0', blocks_tag_debug_1, '0']
- [digital_crc32_bb_1, '0', blocks_repack_bits_bb_1, '0']
- [digital_crc32_bb_1, '0', digital_protocol_formatter_bb_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '1', blocks_vector_to_stream_0, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_2, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', virtual_sink_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_1_0, '0']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_0_0, '0', analog_wfm_tx_0, '0']
- [epy_block_1, msg_out, virtual_sink_3_0, '0']
- [epy_block_2, '0', blocks_stream_to_tagged_stream_0, '0']
- [fft_vxx_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [fft_vxx_2, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, virtual_sink_3, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0, set_msg]
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']
- [virtual_source_0_0, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_1, '0', fft_vxx_1, '0']
- [virtual_source_2, '0', blocks_throttle_0, '0']
- [virtual_source_2_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_2_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_3, '0', epy_block_0_0, weight_msg]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
