options:
  parameters:
    author: pi
    generate_options: qt_gui
    id: mavlinktest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      from pymavlink import mavutil
      import numpy
      import pmt
      import threading

      class pymavlink_source_sink_pp(gr.basic_block):
          def __init__(self, connection_string='udp:localhost:14550', baud_rate=57600):
              gr.basic_block.__init__(self,
                  name="pymavlink_source_sink_pp",
                  in_sig=[],
                  out_sig=[])

              self.connection_string = connection_string
              self.baud_rate = baud_rate

              # Register message ports
              self.message_port_register_in(pmt.intern("MAVLink_IN"))
              self.message_port_register_out(pmt.intern("MAVLink_OUT"))
              self.set_msg_handler(pmt.intern("MAVLink_IN"), self.mavlink_handler)

              # Setup MAVLink connection
              self.mavlink_connection = mavutil.mavlink_connection(connection_string, baud=baud_rate)
              
              # Thread for checking for messages
              self.running = True
              self.thread = threading.Thread(target=self.check_for_message)
              self.thread.daemon = True
              self.thread.start()

          def mavlink_handler(self, msg):
              data = pmt.to_python(pmt.cdr(msg))
              binarrymavlink = bytearray(data)
              mavmessage = self.mavlink_connection.mav.decode(binarrymavlink)
              self.mavlink_connection.write(binarrymavlink)

          def check_for_message(self):
              while self.running:
                  self.message = self.mavlink_connection.recv_match(blocking=True, timeout=10)
                  if self.message is not None:
                      if self.message.get_type() == 'BAD_DATA':
                          continue
                      buf = self.message.get_msgbuf()
                      bufnp = numpy.frombuffer(buf, dtype=numpy.uint8)
                      self.message_port_pub(pmt.intern("MAVLink_OUT"), pmt.cons(pmt.PMT_NIL, pmt.to_pmt(bufnp)))

          def __del__(self):
              self.running = False
              self.mavlink_connection.close()
              if self.thread.is_alive():
                  self.thread.join()

          def work(self, input_items, output_items):
              # Not used in this block, but required for the basic_block
              return len(input_items[0])
    baud_rate: '921600'
    connection_string: '"/dev/ttyUSB0"'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      # 
      # Copyright 2017 Oak Ridge National Laboratory.
      # 
      # This is free software; you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation; either version 3, or (at your option)
      # any later version.
      # 
      # This software is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      # 
      # You should have received a copy of the GNU General Public License
      # along with this software; see the file COPYING.  If not, write to
      # the Free Software Foundation, Inc., 51 Franklin Street,
      # Boston, MA 02110-1301, USA.
      # 
      from __future__ import print_function
      import numpy
      from gnuradio import gr
      import threading

      from pymavlink import mavutil
      import pmt

      class pymavlink_source_p(gr.sync_block):
          """
          pymavlink_sink_p generates a pdu version of MAVlink commands from a MAVLink source.  A good simple interface block although the 2 way requirements of MAVlink control makes the use of this block limited
          """
          def __init__(self, connection_string='udp:localhost:14550', baud_rate=57600):
              gr.sync_block.__init__(self,
                  name="pymavlink_source_p",
                  in_sig=None,
                  out_sig=None)
              self.connection_string=connection_string
              self.baud_rate=baud_rate
              #self.message_port_register_in(pmt.intern("command"))
              #self.set_msg_handler(pmt.intern("command"), self.cmd_handler)
              self.message_port_register_out(pmt.intern("MAVLink"))
              self.mavlink_connection = mavutil.mavlink_connection(connection_string,baud=baud_rate)
              print (self.mavlink_connection)
              self.running=True
              #print self.mavlink_connection
              self.thread = threading.Thread(target=self.check_for_message)
              self.thread.daemon = True
              self.thread.start()
          def check_for_message(self):
              # Make an empty dictionary
              MAVLink_message = pmt.make_dict()
              key =  pmt.intern('mavlink')
              while(self.running):
                 #print ("check_for_message in thread")
                 self.message=self.mavlink_connection.recv_match(blocking=True,timeout=10)
                 if self.message!=None:
                  if self.message.get_type() == 'BAD_DATA':
                      self.message=None
                 if(self.message!=None):
                   #print ("message found")
                   #print (self.message.get_msgbuf())
                   buf=self.message.get_msgbuf()
                   bufnp=numpy.frombuffer(buf,dtype=numpy.uint8)
                   #buf=list(buf)
                   #temp={'mavlink':buf}
                   #temp_pmt=pmt.to_pmt(temp)
                   meta='mavlink'
                   self.message_port_pub(pmt.intern("MAVLink"),pmt.cons(pmt.PMT_NIL,pmt.to_pmt(bufnp)))
                   self.message=None    
          def __del__(self):
              self.running=False
              self.mavlink_connection.close()
              self.thread.close()
          def work(self, input_items, output_items):
              pass
    baud_rate: '921600'
    connection_string: '"/dev/ttyUSB0"'
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      from gtts import gTTS
      from pydub import AudioSegment

      class text_to_wav_block(gr.sync_block):  
          """Embedded Python Block example - converts text to WAV and outputs float32 data"""

          def __init__(self, sample_rate=48000):  
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='text_to_wav_block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.float32]  # Output signal as float32
              )
              self.sample_rate = sample_rate
              self.text = "no input"
              self.filename = "output.wav"
              self.wav_data = np.array([], dtype=np.float32)  # Initialize an empty array for WAV data
              self.message_port_register_in(pmt.intern("MSG_IN"))
              self.set_msg_handler(pmt.intern("MSG_IN"), self.set_text)

          def set_text(self, msg):
              """
              Sets the text to be converted to WAV.
              """
              self.text = str(msg)
              print(msg)
              self.convert_to_wav()

          def convert_to_wav(self):
              """
              Converts the stored text to a WAV file and loads the WAV data for output.
              """
              if self.text:
                  tts = gTTS(text=self.text, lang='en')
                  tts.save("temp.mp3")  # Save as mp3 temporarily

                  # Convert mp3 to wav
                  sound = AudioSegment.from_mp3("temp.mp3")
                  sound = sound.set_frame_rate(self.sample_rate)  # Ensure correct sample rate
                  sound.export(self.filename, format="wav")
                  print(f"Audio saved as {self.filename}")
                  
                  # Load the WAV data into memory as a numpy array
                  self.wav_data = np.array(sound.get_array_of_samples(), dtype=np.float32)
                  
                  # Normalize the data to the range [-1, 1]
                  self.wav_data /= np.iinfo(np.int16).max
                  
                  # Clean up the temporary mp3 file
                  os.remove("temp.mp3")
              else:
                  print("No text provided for conversion.")

          def work(self, input_items, output_items):
              """Output the float32 WAV data"""
              output_length = len(output_items[0])
              data_length = len(self.wav_data)
              
              # Ensure we don't exceed the length of the WAV data
              if data_length > 0:
                  output_items[0][:min(output_length, data_length)] = self.wav_data[:min(output_length, data_length)]
                  self.wav_data = self.wav_data[min(output_length, data_length):]  # Update remaining data
              else:
                  output_items[0][:] = 0  # No data to output

              return len(output_items[0])
    sample_rate: samp_rate
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import numpy as np
      from gtts import gTTS
      from pydub import AudioSegment

      class text_to_wav_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sample_rate=48000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='text_to_wav_block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.sample_rate=sample_rate
              self.text="no input"
              self.filename = "output.wav"
              self.message_port_register_in(pmt.intern("MSG_IN"))
              self.set_msg_handler(pmt.intern("MSG_IN"), self.set_text)


              
          def set_text(self, msg):
                  """
                  Sets the text to be converted to WAV.
                  """
                  # data = pmt.to_python(pmt.cdr(msg))
                  self.text = str(msg)
                  print(msg)
                  self.convert_to_wav()
          def convert_to_wav(self):
              """
              Converts the stored text to a WAV file and loads the WAV data for output.
              """
              if self.text and len(self.text):
                  tts = gTTS(text=self.text, lang='en')
                  tts.save("temp.mp3")  # Save as mp3 temporarily

                  # Convert mp3 to wav
                  sound = AudioSegment.from_mp3("temp.mp3")
                  sound = sound.set_frame_rate(self.sample_rate)  # Ensure correct sample rate
                  sound.export(self.filename, format="wav")
                  print(f"Audio saved as {self.filename}")
                  
                  # Load the WAV data into memory as a numpy array
                  # self.wav_data = np.array(sound.get_array_of_samples(), dtype=np.float32)
                  
                  # Normalize the data to the range [-1, 1]
                  # self.wav_data /= np.iinfo(np.int16).max
                  
                  # Clean up the temporary mp3 file
                  os.remove("temp.mp3")
              else:
                  print("No text provided for conversion.")

                  
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    sample_rate: samp_rate
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      # 
      # Copyright 2017 Oak Ridge National Laboratory.
      # 
      # This is free software; you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation; either version 3, or (at your option)
      # any later version.
      # 
      # This software is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      # 
      # You should have received a copy of the GNU General Public License
      # along with this software; see the file COPYING.  If not, write to
      # the Free Software Foundation, Inc., 51 Franklin Street,
      # Boston, MA 02110-1301, USA.
      # 

      from __future__ import print_function
      import numpy
      from gnuradio import gr
      import threading

      from pymavlink import mavutil
      import pmt
      from builtins import object

      #from pymavlink.dialects.v10 import ardupilotmega as mavlink
      #from pymavlink.dialects.v20 import ardupilotmega as mavlink2


      class pymavlink_sink_p(gr.sync_block):
          """
          pymavlink_sink_p accepts pdu version of MAVlink commands and submits they to a MAVLink based flight control or GCS.  A good simple interface block although the 2 way requirements of MAVlink control makes the use of this block limited
          """
          def __init__(self, connection_string='udp:localhost:14550',baud_rate=57600):
              gr.sync_block.__init__(self,
                  name="pymavlink_sink_p",
                  in_sig=None,
                  out_sig=None)
              self.connection_string=connection_string
              self.baud_rate=baud_rate
              #self.message_port_register_in(pmt.intern("command"))
              #self.set_msg_handler(pmt.intern("command"), self.cmd_handler)
              self.message_port_register_in(pmt.intern("MAVLink"))
              self.mavlink_connection = mavutil.mavlink_connection(connection_string,baud=baud_rate)
              self.set_msg_handler(pmt.intern("MAVLink"), self.mavlink_handler) 
              print (self.mavlink_connection)
                  # we will use a fifo as an encode/decode buffer
                      
          def mavlink_handler(self,msg):
              meta = pmt.car(msg);
              data = pmt.to_python(pmt.cdr(msg));
              #turn message back to buf to send through the connection
              #data = pmt.to_python((msg))
              #print (type(data))
              #print (data['mavlink'])
              binarrymavlink=bytearray(data)
              mavmessage=self.mavlink_connection.mav.decode(binarrymavlink)
              #print(mavmessage)
              self.mavlink_connection.write(binarrymavlink)
              #ref = pmt.dict_ref(data, key0, pmt.PMT_NIL)
              #print (ref)
          def __del__(self):
              self.mavlink_connection.close()
              
          def work(self, input_items, output_items):
              pass
    baud_rate: '921600'
    connection_string: '"/dev/ttyUSB0"'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      # 
      # Copyright 2017 Oak Ridge National Laboratory.
      # 
      # This is free software; you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation; either version 3, or (at your option)
      # any later version.
      # 
      # This software is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      # 
      # You should have received a copy of the GNU General Public License
      # along with this software; see the file COPYING.  If not, write to
      # the Free Software Foundation, Inc., 51 Franklin Street,
      # Boston, MA 02110-1301, USA.
      # 

      from __future__ import print_function
      import numpy
      from gnuradio import gr
      import threading
      import datetime as dt
      import time

      from pymavlink import mavutil
      import pmt
      from builtins import object

      #from pymavlink.dialects.v10 import ardupilotmega as mavlink

      class mavlink_control(gr.sync_block):
          """
          This is used to receive messages from a control gui for flight control of a MAVLink device.  This block turns PMT control messages into MAVLink messages.  This block creates two instances of pymavlink connections to handle the data flow.  This currently emulates the basics of a GCS and provides data in such a way that MavProxy can connect to it for debugging processes.  This block also sends 1 second heartbeat messages to maintain the MAVLink link with a pixhawk flight controller.
          """
          def __init__(self, connection_string="0.0.0.0:14400",baud_rate=57600):
              gr.sync_block.__init__(self,
                  name="mavlink_control",
                  in_sig=None,
                  out_sig=None)


              self.connection_string=connection_string
              self.baud_rate=baud_rate
              #self.message_port_register_in(pmt.intern("command"))
              #self.set_msg_handler(pmt.intern("command"), self.cmd_handler)
              self.message_port_register_in(pmt.intern("MAVLink_IN"))
              self.message_port_register_in(pmt.intern("Command"))
              self.message_port_register_out(pmt.intern("MAVLink_OUT"))
              self.mavlink_connection = mavutil.mavlink_connection('udpout:'+connection_string,baud=baud_rate)
              self.mavlink2=mavutil.mavlink_connection('udpin:'+connection_string,baud=baud_rate)
              self.set_msg_handler(pmt.intern("MAVLink_IN"), self.mavlink_handler)
              self.set_msg_handler(pmt.intern("Command"), self.command_handler)
              print (self.mavlink_connection)
              self.running=True
              self.takeoff=0
              #print self.mavlink_connection
              self.thread = threading.Thread(target=self.check_for_message)
              self.thread.daemon = True
              self.thread.start()
              self.thread2 = threading.Thread(target=self.check_for_message2)
              self.thread2.daemon = True
              self.thread2.start()
              self.data=data=[0]*8
              self.last_heartbeat_time=dt.datetime.now()
              self.thread3=threading.Thread(target=self.send_heartbeat)
              self.thread3.daemon = True
              self.thread3.start()
              
          
          def set_land(self):
              self.takeoff=0
              self.mavlink2.set_mode('LAND')
          
          #def set_servo(self,data):
          #    print(self.data)
          #    print(data)
          #    for i in range (3):
          #        if self.data[i] != data[i]:
          #            self.mavlink2.set_servo(i+1,data[i])
          #            print('servo ' + str(i+1) + 'set to ' +str(data[i]))
              #self.mavlink2.set_servo(channel,pwm)
          def set_channel_overrides(self,data):
               #using set_overrides prevenet the controler of solo from taking command of a out of control UAS
               #self.set_servo(data) #temporary replace for test test set_channel_overrides
               self.mavlink2.mav.rc_channels_override_send(
      			self.mavlink2.target_system, self.mavlink2.target_component, *data)
          
          def arm_and_takeoff(self,data):
              #current_location=self.mavlink_connection.location(True)
              #print (current_location)
              if (self.takeoff==1):
                  print ('currently in takeoff mode, switch to land mode before attempting again')
                  return
              self.last_heartbeat_time=dt.datetime.now()
              self.takeoff=1
              print ("hold")
       
              #data=[0]*8
              #should be 1500 for alt_hold
              self.data[0]=data[0]
              self.data[1]=data[1]
              self.data[2]=data[2]
              
              print('before overide')
              self.set_channel_overrides(self.data)
              time.sleep(0.5)
              #Get the motors working after arming (stablilze requires an input)
              #print('set servos')
              #self.mavlink2.set_relay(1)
              #self.mavlink2.set_relay(2)
              #self.mavlink2.set_relay(3)
              #self.mavlink2.set_servo(1,self.data[0])
              #self.mavlink2.set_servo(2,self.data[1])
              #self.mavlink2.set_servo(3,self.data[2])
              #print(self.data)
              #print('after servo')
              if(data[7]==0):
                self.mavlink2.set_mode('STABILIZE')
              elif(data[7]==1):
                self.mavlink2.set_mode('ALT_HOLD')
              elif(data[7]==2):
                self.mavlink2.set_mode('LOITER')
              time.sleep(0.5)
              print('first set')
              
              if not self.mavlink2.motors_armed(): # Function to check if UAV is armed
                print('in_Armed')
                self.mavlink2.arducopter_arm() # Function to ARM the UAV
                time.sleep(0.3)
                print('Armed called')
                #Do not proceed until the UAV is armed
                #self.mavlink2.motors_armed_wait() # Function to wait till the UAV is armed
                print ('Armed wait')
                
                #give up throttle
                #self.data[2]=self.data[2]+150
                tempdata=[0]*8
                tempdata[0]=data[0]
                tempdata[1]=data[1]
                tempdata[2]=data[2]
                tempdata[2]=tempdata[2]+200
                print('before override set')
                #self.set_servo(tempdata)
                self.set_channel_overrides(tempdata)
                
                print('after override')
                
                
                  
          def command_handler(self,msg):
              print ('receive message')
              meta =  pmt.to_python(pmt.car(msg))
              data = pmt.to_python(pmt.cdr(msg))
              print (meta)
              print (data)
              if meta == 'takeoff':
                 print ('call takeoff')
                 self.arm_and_takeoff(data)
              elif meta == 'rc_override':
                 print (data)
                 #self.data=data
                 print ('rc_override')
                 #self.set_servo(data)
                 self.set_channel_overrides(data)
                 self.data=data
              elif meta == 'land':
                 print('land')
                 self.set_land()
              elif meta == 'disarm':
                 print('disarm')
                 self.disarm() 
              elif meta == 'heartbeat':
                 print('heartbeat')
                 self.receive_hearbeat()
                 
          def mavlink_handler(self,msg):
              meta = pmt.car(msg)
              data = pmt.to_python(pmt.cdr(msg))
              binarrymavlink=bytearray(data)
              mavmessage=self.mavlink_connection.mav.decode(binarrymavlink)
              #print(mavmessage)
              self.mavlink_connection.write(binarrymavlink)
             
          def send_heartbeat(self):
              self.mavlink2.wait_heartbeat()
              while(self.running):
                if (self.takeoff!=0):
                  currentimem5=dt.datetime.now()-dt.timedelta(seconds=5)
                  print('in send_heartbeat')
                  print(currentimem5)
                  print(self.last_heartbeat_time)
                  if(currentimem5>self.last_heartbeat_time): #if we have missed all messages for more than 5 seconds
                    print('lost link')
                    self.set_land()
                    
                  if (self.takeoff!=0):
                    self.mavlink2.mav.heartbeat_send(mavutil.mavlink.MAV_TYPE_GCS, mavutil.mavlink.MAV_AUTOPILOT_INVALID,
                                        0, 0, 0)
                    self.set_channel_overrides(self.data)
                time.sleep(1.0)
          def disarm(self):
              self.data[0]=0
              self.data[1]=0
              self.data[2]=0
              self.mavlink2.arducopter_disarm()
          
          def receive_hearbeat(self):
              print('heartbeat received')
              self.last_heartbeat_time=dt.datetime.now()
              print(self.last_heartbeat_time)
          
          def check_for_message(self):
              # Make an empty dictionary
              MAVLink_message = pmt.make_dict()
              key =  pmt.intern('mavlink')
              while(self.running):
                 #print ("check_for_message in thread")
                 self.message=self.mavlink_connection.recv_match(blocking=True, timeout=10)
                 if self.message!=None:
                  if self.message.get_type() == 'BAD_DATA':
                      self.message=None
                 if(self.message!=None):
                   #print ("message_1 found")
                   #print (self.message)
                   buf=self.message.get_msgbuf()
                   bufnp=numpy.frombuffer(buf,dtype=numpy.uint8)
                   meta='mavlink'
                   self.message_port_pub(pmt.intern("MAVLink_OUT"),pmt.cons(pmt.PMT_NIL,pmt.to_pmt(bufnp)))
                   self.message=None        
          
          
          def check_for_message2(self):
              # Make an empty dictionary
              MAVLink_message = pmt.make_dict()
              key =  pmt.intern('mavlink')
              while(self.running):
                 #print ("check_for_message in thread")
                 self.message2=self.mavlink2.recv_match(blocking=True, timeout=10)
                 if self.message2!=None:
                  if self.message2.get_type() == 'BAD_DATA':
                      self.message2=None
                 if(self.message2!=None):
                   #print ("message_2 found")
                   #print (self.message2)
                   buf=self.message2.get_msgbuf()
                   bufnp=numpy.frombuffer(buf,dtype=numpy.uint8)
                   meta='mavlink'
                   #self.message_port_pub(pmt.intern("MAVLink_OUT"),pmt.cons(pmt.PMT_NIL,pmt.to_pmt(bufnp)))
                   self.message2=None    
          
          def __del__(self):
              self.running=False
              self.mavlink_connection.close()
              self.mavlink2.close()
              self.thread.close()       
              self.thread2.close()
              self.thread3.close()
              
             

          def work(self, input_items, output_items):
              pass
    baud_rate: '921600'
    connection_string: '""'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      # 
      # Copyright 2017 Oak Ridge National Laboratory.
      # 
      # This is free software; you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation; either version 3, or (at your option)
      # any later version.
      # 
      # This software is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      # 
      # You should have received a copy of the GNU General Public License
      # along with this software; see the file COPYING.  If not, write to
      # the Free Software Foundation, Inc., 51 Franklin Street,
      # Boston, MA 02110-1301, USA.
      # 

      import numpy
      from gnuradio import gr
      import pmt

      class pdu_control_to_pdu_vector(gr.sync_block):
          """
          pdu_control_to_pdu_vector converts a control message from pdu sent over zmq to a vector of 8 bit ints required for packet based processin.  It also incodes message infromation into the data
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="pdu_control_to_pdu_vector",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_in(pmt.intern("Control_IN"))
              self.message_port_register_out(pmt.intern("Vector_OUT"))
              self.data=[0]*9
              self.set_msg_handler(pmt.intern("Control_IN"), self.control_handler)
              
          def control_handler(self,msg):
              meta =  pmt.to_python(pmt.car(msg))
              data = pmt.to_python(pmt.cdr(msg))
              #print data
              if meta == 'takeoff':
                 self.data[8]=1
              elif meta == 'land':
                 self.data[8]=2   
              elif meta == 'rc_override':
                 self.data[8]=3
                 print (data)
              elif meta == 'disarm':
                 self.data[8]=4
              elif meta == 'heartbeat':
                  self.data[8]=5
              self.data[0]=data[0]
              self.data[1]=data[1]
              self.data[2]=data[2]
              self.data[7]=data[7]
              ndata=numpy.array(self.data,dtype=numpy.int32)
              nbytes=ndata.tobytes()
              bufnp=numpy.frombuffer(nbytes,dtype=numpy.uint8)
              
              self.message_port_pub(pmt.intern("Vector_OUT"),pmt.cons(pmt.PMT_NIL,pmt.to_pmt(bufnp)))
             
          def work(self, input_items, output_items):
              pass
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      # 
      # Copyright 2017 Oak Ridge National Laboratory.
      # 
      # This is free software; you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation; either version 3, or (at your option)
      # any later version.
      # 
      # This software is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      # 
      # You should have received a copy of the GNU General Public License
      # along with this software; see the file COPYING.  If not, write to
      # the Free Software Foundation, Inc., 51 Franklin Street,
      # Boston, MA 02110-1301, USA.
      # 

      import numpy
      from gnuradio import gr
      import pmt

      class pdu_vector_to_pdu_control(gr.sync_block):
          """
          pdu_vector_to_pdu_control converts a pdu vector of 8 bit ints into a pdu control message designed for further processing in the system.  It also incodes message information into the data vector
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="pdu_vector_to_pdu_control",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_in(pmt.intern("Vector_IN"))
              self.message_port_register_out(pmt.intern("Control_OUT"))
              self.data=[0]*8
              self.set_msg_handler(pmt.intern("Vector_IN"), self.vector_handler)

          def vector_handler(self,msg):
              meta =  pmt.to_python(pmt.car(msg))
              databuf = pmt.to_python(pmt.cdr(msg))
              data=numpy.frombuffer(databuf,dtype=numpy.uint32)
              print ("vector handler")
              print (data)
              self.data[0]=int(data[0])
              self.data[1]=int(data[1])
              self.data[2]=int(data[2])
              self.data[7]=int(data[7])
              if(data[8]==1):
                meta = pmt.to_pmt('takeoff')
                pmtdata = pmt.to_pmt(self.data)
                msg=pmt.cons(meta, pmtdata)
              elif(data[8]==2):
                meta = pmt.to_pmt('land')
                pmtdata = pmt.to_pmt(self.data)
                msg=pmt.cons(meta, pmtdata)  
              elif(data[8]==3):
                meta = pmt.to_pmt('rc_override')
                pmtdata = pmt.to_pmt(self.data)
                msg=pmt.cons(meta, pmtdata)
              elif(data[8]==4):
                meta = pmt.to_pmt('disarm')
                pmtdata = pmt.to_pmt(self.data)
                msg=pmt.cons(meta, pmtdata)
              elif(data[8]==5):
                meta = pmt.to_pmt('heartbeat')
                pmtdata = pmt.to_pmt(self.data)
                msg=pmt.cons(meta, pmtdata)
              self.message_port_pub(pmt.intern("Control_OUT"),msg)
              
          def work(self, input_items, output_items):
              pass
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"enter message"'
    type: string
    value: '"hello world"'
  states: {}

connections:
- [qtgui_edit_box_msg_0_0, msg, epy_block_1_0, MSG_IN]
- [qtgui_edit_box_msg_0_0, msg, epy_block_1_0_0, MSG_IN]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
