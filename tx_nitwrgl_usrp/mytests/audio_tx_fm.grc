options:
  parameters:
    generate_options: qt_gui
    id: audio_tx_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 100e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '40000'
    fh: '-1'
    max_dev: 75e3
    quad_rate: '400000'
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/Desktop/project/output.wav
    repeat: 'True'
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import numpy as np
      from gtts import gTTS
      from pydub import AudioSegment

      class text_to_wav_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sample_rate=48000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='text_to_wav_block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.sample_rate=sample_rate
              self.text="no input"
              self.filename = "output.wav"
              self.message_port_register_in(pmt.intern("MSG_IN"))
              self.set_msg_handler(pmt.intern("MSG_IN"), self.set_text)


              
          def set_text(self, msg):
                  """
                  Sets the text to be converted to WAV.
                  """
                  # data = pmt.to_python(pmt.cdr(msg))
                  self.text = str(msg)
                  print(msg)
                  self.convert_to_wav()
          def convert_to_wav(self):
              """
              Converts the stored text to a WAV file and loads the WAV data for output.
              """
              if self.text and len(self.text):
                  tts = gTTS(text=self.text, lang='en')
                  tts.save("temp.mp3")  # Save as mp3 temporarily

                  # Convert mp3 to wav
                  sound = AudioSegment.from_mp3("temp.mp3")
                  sound = sound.set_frame_rate(self.sample_rate)  # Ensure correct sample rate
                  sound.export(self.filename, format="wav")
                  print(f"Audio saved as {self.filename}")
                  
                  # Load the WAV data into memory as a numpy array
                  # self.wav_data = np.array(sound.get_array_of_samples(), dtype=np.float32)
                  
                  # Normalize the data to the range [-1, 1]
                  # self.wav_data /= np.iinfo(np.int16).max
                  
                  # Clean up the temporary mp3 file
                  os.remove("temp.mp3")
              else:
                  print("No text provided for conversion.")

                  
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    sample_rate: samp_rate
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      from gtts import gTTS
      from pydub import AudioSegment

      class text_to_wav_block(gr.sync_block):  
          """Embedded Python Block example - converts text to WAV and outputs float32 data"""

          def __init__(self, sample_rate=48000):  
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='text_to_wav_block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.float32]  # Output signal as float32
              )
              self.sample_rate = sample_rate
              self.text = "no input"
              self.filename = "output.wav"
              self.wav_data = np.array([], dtype=np.float32)  # Initialize an empty array for WAV data
              self.message_port_register_in(pmt.intern("MSG_IN"))
              self.set_msg_handler(pmt.intern("MSG_IN"), self.set_text)

          def set_text(self, msg):
              """
              Sets the text to be converted to WAV.
              """
              self.text = str(msg)
              print(msg)
              self.convert_to_wav()

          def convert_to_wav(self):
              """
              Converts the stored text to a WAV file and loads the WAV data for output.
              """
              if self.text:
                  tts = gTTS(text=self.text, lang='en')
                  tts.save("temp.mp3")  # Save as mp3 temporarily

                  # Convert mp3 to wav
                  sound = AudioSegment.from_mp3("temp.mp3")
                  sound = sound.set_frame_rate(self.sample_rate)  # Ensure correct sample rate
                  sound.export(self.filename, format="wav")
                  print(f"Audio saved as {self.filename}")
                  
                  # Load the WAV data into memory as a numpy array
                  self.wav_data = np.array(sound.get_array_of_samples(), dtype=np.float32)
                  
                  # Normalize the data to the range [-1, 1]
                  self.wav_data /= np.iinfo(np.int16).max
                  
                  # Clean up the temporary mp3 file
                  os.remove("temp.mp3")
              else:
                  print("No text provided for conversion.")

          def work(self, input_items, output_items):
              """Output the float32 WAV data"""
              output_length = len(output_items[0])
              data_length = len(self.wav_data)
              
              # Ensure we don't exceed the length of the WAV data
              if data_length > 0:
                  output_items[0][:min(output_length, data_length)] = self.wav_data[:min(output_length, data_length)]
                  self.wav_data = self.wav_data[min(output_length, data_length):]  # Update remaining data
              else:
                  output_items[0][:] = 0  # No data to output

              return len(output_items[0])
    sample_rate: samp_rate
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 70e3
    decim: '40'
    gain: '100'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"enter message"'
    type: string
    value: '""'
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"enter message"'
    type: string
    value: '"hello world"'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '50'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '50'
    type: fcc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 107.5e6
    gain0: '50'
    samp_rate: '2000000'
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 88.5e6
    gain0: '50'
    samp_rate: '2000000'
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 107.5e6
    gain0: '50'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [epy_block_1_0_0, '0', analog_wfm_tx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_1_0, MSG_IN]
- [qtgui_edit_box_msg_0_0_0, msg, epy_block_1_0_0, MSG_IN]
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', uhd_usrp_sink_0_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
