options:
  parameters:
    generate_options: qt_gui
    id: fec_txt_transfer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decoder_def_0
  id: variable_repetition_decoder_def
  parameters:
    framebits: '12000'
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {state: disabled}
- name: encoder_def_0
  id: variable_repetition_encoder_def
  parameters:
    framebits: '12000'
    ndim: '0'
    rep: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pi/Desktop/project/mytests/demo1.txt
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pi/Desktop/project/mytests/demo.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: decoder_def_0
    itype: byte
  states: {state: disabled}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: encoder_def_0
    itype: byte
    otype: byte
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200000'
    decim: '1'
    gain: '1'
    samp_rate: '400000'
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '1000000000'
    dev_addr: ''
    gain0: '3000000000'
    samp_rate: '400000'
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '1000000000'
    dev_addr: ''
    gain0: '30'
    samp_rate: '400000'
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', fec_generic_encoder_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', low_pass_filter_0, '0']
- [digital_gmsk_demod_0, '0', fec_generic_decoder_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [fec_generic_decoder_0, '0', blocks_file_sink_0, '0']
- [fec_generic_encoder_0, '0', digital_gmsk_mod_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
