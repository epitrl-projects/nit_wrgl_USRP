options:
  parameters:
    category: Custom
    description: Example of an OFDM receiver
    generate_options: qt_gui
    id: tx_rx_ofdm
    output_language: python
    title: OFDM Tx Rx
  states: {}

blocks:
- name: central_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_16qam()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate_1
  id: variable_qtgui_range
  parameters:
    label: TX_SAMPLE
    start: '0'
    step: '1'
    stop: '500000'
    value: '20000'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '30000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pi/Desktop/project/final_test_successed/data_rx
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: rx_frames_time
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pi/Desktop/project/mytests/demo.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '96'
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: packet_length_tag_key
    name: Rx from mission planner
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 0.7+ 0.7j
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate_rx
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: packet_length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    tagname: packet_length_tag_key
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.99'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: packet_length_tag_key
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      from pymavlink import mavutil
      import numpy
      import pmt
      import threading
      import time

      class pymavlink_source_sink_pp(gr.basic_block):
          def __init__(self, connection_string='udp:localhost:14550', baud_rate=57600):
              gr.basic_block.__init__(self,
                  name="pymavlink_source_sink_pp",
                  in_sig=[],
                  out_sig=[])

              self.connection_string = connection_string
              self.baud_rate = baud_rate
              self.sendbuffer=None

              # Register message ports
              self.message_port_register_in(pmt.intern("MAVLink_IN"))
              self.message_port_register_out(pmt.intern("MAVLink_OUT"))
              self.set_msg_handler(pmt.intern("MAVLink_IN"), self.mavlink_handler)

              # Setup MAVLink connection
              self.mavlink_connection = mavutil.mavlink_connection(connection_string, baud=baud_rate)
              
              # Thread for checking for messages
              self.running = True
              self.thread = threading.Thread(target=self.check_for_message)
              self.thread.daemon = True
              self.thread.start()
             
          def mavlink_handler(self, msg):
              data = pmt.to_python(pmt.cdr(msg))
              binarrymavlink = bytearray(data)
              mavmessage = self.mavlink_connection.mav.decode(binarrymavlink)
              print("from gcs",mavmessage)
              self.mavlink_connection.write(binarrymavlink)

          def check_for_message(self):
              self.mavlink_connection.mav.param_request_list_send(
                      self.mavlink_connection.target_system,
                      self.mavlink_connection.target_component
                  )
              while self.running:
                  
                  self.message = self.mavlink_connection.recv_match(blocking=True, timeout=10)
                  self.sendbuffer = self.message
                  if self.message is not None:
                      if self.message.get_type() == 'BAD_DATA':
                          continue
                      
                          
                      buf = self.message.get_msgbuf()
                      bufnp = numpy.frombuffer(buf, dtype=numpy.uint8)
                      #print("to gcs",self.message)
                      
                      self.message_port_pub(pmt.intern("MAVLink_OUT"), pmt.cons(pmt.PMT_NIL, pmt.to_pmt(bufnp)))

          def __del__(self):
              self.running = False
              self.mavlink_connection.close()
              if self.thread.is_alive():
                  self.thread.join()

          def work(self, input_items, output_items):
              # Not used in this block, but required for the basic_block
              return len(input_items[0])
    baud_rate: '921600'
    connection_string: '"udp:0.0.0.0:2346"'
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      # 
      # Copyright 2017 Oak Ridge National Laboratory.
      # 
      # This is free software; you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation; either version 3, or (at your option)
      # any later version.
      # 
      # This software is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      # 
      # You should have received a copy of the GNU General Public License
      # along with this software; see the file COPYING.  If not, write to
      # the Free Software Foundation, Inc., 51 Franklin Street,
      # Boston, MA 02110-1301, USA.
      # 
      from __future__ import print_function
      import numpy
      from gnuradio import gr
      import threading

      from pymavlink import mavutil
      import pmt

      class pymavlink_source_p(gr.sync_block):
          """
          pymavlink_sink_p generates a pdu version of MAVlink commands from a MAVLink source.  A good simple interface block although the 2 way requirements of MAVlink control makes the use of this block limited
          """
          def __init__(self, connection_string='udp:localhost:14550', baud_rate=57600):
              gr.sync_block.__init__(self,
                  name="pymavlink_source_p",
                  in_sig=None,
                  out_sig=None)
              self.connection_string=connection_string
              self.baud_rate=baud_rate
              #self.message_port_register_in(pmt.intern("command"))
              #self.set_msg_handler(pmt.intern("command"), self.cmd_handler)
              self.message_port_register_out(pmt.intern("MAVLink"))
              self.mavlink_connection = mavutil.mavlink_connection(connection_string,baud=baud_rate)
              print (self.mavlink_connection)
              self.running=True
              #print self.mavlink_connection
              self.thread = threading.Thread(target=self.check_for_message)
              self.thread.daemon = True
              self.thread.start()
          def check_for_message(self):
              # Make an empty dictionary
              MAVLink_message = pmt.make_dict()
              key =  pmt.intern('mavlink')
              while(self.running):
                 #print ("check_for_message in thread")
                 self.message=self.mavlink_connection.recv_match(blocking=True,timeout=10)
                 if self.message!=None:
                  if self.message.get_type() == 'BAD_DATA':
                      self.message=None
                 if(self.message!=None):
                   #print ("message found")
                   #print (self.message.get_msgbuf())
                   buf=self.message.get_msgbuf()
                   bufnp=numpy.frombuffer(buf,dtype=numpy.uint8)
                   #buf=list(buf)
                   #temp={'mavlink':buf}
                   #temp_pmt=pmt.to_pmt(temp)
                   meta='mavlink'
                   self.message_port_pub(pmt.intern("MAVLink"),pmt.cons(pmt.PMT_NIL,pmt.to_pmt(bufnp)))
                   self.message=None    
          def __del__(self):
              self.running=False
              self.mavlink_connection.close()
              self.thread.close()
          def work(self, input_items, output_items):
              pass
    baud_rate: '921600'
    connection_string: '"udp:0.0.0.0:2346"'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      # 
      # Copyright 2017 Oak Ridge National Laboratory.
      # 
      # This is free software; you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation; either version 3, or (at your option)
      # any later version.
      # 
      # This software is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      # 
      # You should have received a copy of the GNU General Public License
      # along with this software; see the file COPYING.  If not, write to
      # the Free Software Foundation, Inc., 51 Franklin Street,
      # Boston, MA 02110-1301, USA.
      # 

      from __future__ import print_function
      import numpy
      from gnuradio import gr
      import threading

      from pymavlink import mavutil
      import pmt
      from builtins import object

      #from pymavlink.dialects.v10 import ardupilotmega as mavlink
      #from pymavlink.dialects.v20 import ardupilotmega as mavlink2


      class pymavlink_sink_p(gr.sync_block):
          """
          pymavlink_sink_p accepts pdu version of MAVlink commands and submits they to a MAVLink based flight control or GCS.  A good simple interface block although the 2 way requirements of MAVlink control makes the use of this block limited
          """
          def __init__(self, connection_string='udp:localhost:14550',baud_rate=57600):
              gr.sync_block.__init__(self,
                  name="pymavlink_sink_p",
                  in_sig=None,
                  out_sig=None)
              self.connection_string=connection_string
              self.baud_rate=baud_rate
              #self.message_port_register_in(pmt.intern("command"))
              #self.set_msg_handler(pmt.intern("command"), self.cmd_handler)
              self.message_port_register_in(pmt.intern("MAVLink"))
              self.mavlink_connection = mavutil.mavlink_connection(connection_string,baud=baud_rate)
              self.set_msg_handler(pmt.intern("MAVLink"), self.mavlink_handler) 
              print (self.mavlink_connection)
                  # we will use a fifo as an encode/decode buffer
                      
          def mavlink_handler(self,msg):
              meta = pmt.car(msg);
              data = pmt.to_python(pmt.cdr(msg));
              #turn message back to buf to send through the connection
              #data = pmt.to_python((msg))
              #print (type(data))
              #print (data['mavlink'])
              binarrymavlink=bytearray(data)
              mavmessage=self.mavlink_connection.mav.decode(binarrymavlink)
              print("received from pc",mavmessage)
              self.mavlink_connection.write(binarrymavlink)
              #ref = pmt.dict_ref(data, key0, pmt.PMT_NIL)
              #print (ref)
          def __del__(self):
              self.mavlink_connection.close()
              
          def work(self, input_items, output_items):
              pass
    baud_rate: '921600'
    connection_string: '"udp:0.0.0.0:2346"'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx payload"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate_rx
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: '"Rx signal"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Tx freq"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Rx packed"'
    size: '1024'
    srate: samp_rate_rx
    type: float
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 915e6
    gain0: '10'
    samp_rate: samp_rate_1
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 915e6
    dev_args: '""'
    gain0: '10'
    rx_agc0: Disabled
    samp_rate: samp_rate_1
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: '11'
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: '22'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: '11'
  states: {state: disabled}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: '22'
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_2_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tag_gate_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_1, '0']
- [blocks_tag_gate_0, '0', virtual_sink_2, '0']
- [blocks_tagged_stream_mux_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_0_0_0_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_delay_0, '0']
- [channels_channel_model_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [digital_crc32_bb_0, '0', blocks_tag_debug_1, '0']
- [digital_crc32_bb_1, '0', blocks_repack_bits_bb_1, '0']
- [digital_crc32_bb_1, '0', digital_protocol_formatter_bb_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '1', blocks_vector_to_stream_0, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_2, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', virtual_sink_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_1_0, '0']
- [epy_block_0, MAVLink_OUT, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_1_0, MAVLink, pdu_pdu_to_tagged_stream_0, pdus]
- [fft_vxx_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [fft_vxx_2, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_2, MAVLink]
- [pdu_tagged_stream_to_pdu_0, pdus, virtual_sink_3, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']
- [virtual_source_0_0, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_1, '0', fft_vxx_1, '0']
- [virtual_source_2, '0', blocks_throttle_0, '0']
- [virtual_source_2_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_2_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_3, '0', epy_block_0, MAVLink_IN]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
